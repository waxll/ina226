# Keil uVision project INA226.uvprojx, settings and files
target STM32F103CB (6190000::V6.19::ARMCLANG)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.1.4
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: INA226 +hex
  AfterMake: C:\Users\XieSenshi\Desktop\ina226\MDK-ARM\loadfile.bat
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER UART_OUT
  c include: ..\USER;..\LIB\inc;..\RTT;..\HARDWARE\iic;..\HARDWARE\led;..\HARDWARE\uart;..\APP\ina226;..\APP\oled;..\SYSTEM\delay;..\SYSTEM\sys;..\CORE;..\HARDWARE\i2c;..\SYSTEM\printf;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group APP
    ../APP/ina226/: ina226.c
    ../APP/oled/: oled.c
    ../APP/: iwdg.c iwdg.h
  group HARDWARE
    ../HARDWARE/led/: led.c
    ../HARDWARE/uart/: uart.c
    ../HARDWARE/i2c/: myiic.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/printf/: printf.c
  group SEGGER/RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SETUP
    ../SETUP/: startup_stm32f10x_md.s
