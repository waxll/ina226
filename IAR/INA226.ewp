# IAR project INA226.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER; RTT_OUT
  ICCARM.CCIncludePath2: ..\APP\ina226; ..\APP\oled; ..\CORE; ..\HARDWARE\i2c; ..\HARDWARE\led; ..\HARDWARE\uart; ..\LIB\inc; ..\RTT; ..\SYSTEM\delay; ..\SYSTEM\printf; ..\SYSTEM\sys; ..\USER; ..\APP
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: INA226.hex
  ILINK.IlinkOutputFile: INA226.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP/ina226
    ../APP/ina226/: ina226.c
  group APP/iwdg
    ../APP/: iwdg.c
  group APP/oled
    ../APP/oled/: oled.c
  group HARDWARE/i2c
    ../HARDWARE/i2c/: myiic.c
  group HARDWARE/led
    ../HARDWARE/led/: led.c
  group HARDWARE/uart
    ../HARDWARE/uart/: uart.c
  group LIB
    ../LIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group RTT
    ../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group SETUP
    ../SETUP/iar/: startup_stm32f10x_md.s
  group SYSTEM/delay
    ../SYSTEM/delay/: delay.c
  group SYSTEM/printf
    ../SYSTEM/printf/: printf.c
  group SYSTEM/sys
    ../SYSTEM/sys/: sys.c
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
